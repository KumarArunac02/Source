## NewDriversLinuxDistri/my_c_dev/Kconfig
```kconfig
menuconfig CUSTOM_HELLOWORLD
config CUSTOM_HELLOWORLD
    tristate "hello world module support"
    default n
```
